SUMMARY = "Meta-Article - Toradex Reference Image"
DESCRIPTION = "Meta-Article - Image for BSP verification with QT and multimedia features"

IMAGE_INSTALL += " custom-qt-app "
